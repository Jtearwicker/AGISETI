options:
  parameters:
    author: jtear
    generate_options: qt_gui
    id: Voyager_plot
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2929690'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\jtear\Downloads\blc3_guppi_57386_VOYAGER1_0004.0000_only_vgr1_chan.ci8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-291360'
    decim: '35'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate/decimation, 800, 50)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"green"'
    ctrlpanel: 'True'
    fc: 8431e6
    fftsize: '4096'
    label: Power Spectral Density
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: window.WIN_HAMMING
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
