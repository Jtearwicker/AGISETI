options:
  parameters:
    author: vishalgajjar
    generate_options: qt_gui
    id: Voyager_file_playback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chan_centre
  id: variable
  parameters:
    value: '8420507812.5'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '42'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '500'
  states: {}
- name: decimation2sb
  id: variable
  parameters:
    value: '50'
  states: {}
- name: decimation_0
  id: variable
  parameters:
    value: '35'
  states: {}
- name: diameter
  id: variable_qtgui_range
  parameters:
    label: Diameter of the Telescope
    rangeType: int
    start: '1'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: distance
  id: variable_qtgui_range
  parameters:
    label: Distance to Voyager
    rangeType: int
    start: '1'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '256'
  states: {}
- name: nfftsb
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: voyager_freq
  id: variable
  parameters:
    value: 8420.2164537e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '(distance**2)/(diameter**2) '
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/vishalgajjar/Documents/ARDC/Week7_Data_Science/blc3_guppi_57386_VOYAGER1_0004.0000_only_vgr1_chan.ci8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: voyager_freq - chan_centre
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 35e3, 5e3)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,2
    label1: Voyager 1
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
