options:
  parameters:
    author: jtear
    generate_options: qt_gui
    id: ATA_HI_Integrated
    output_language: python
    title: ATA Hydrogen Integrated
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: int(integration_time*samp_rate/nfft)
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: num_integrations
  id: variable
  parameters:
    value: int(np.round(samp_rate / nfft * integration_time))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\jtear\OneDrive\Desktop\Ata_obs\15_02_53_+40_17_29_offplane
    type: float
    vlen: nfft
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*obs_duration)
    type: complex
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: decimation
    type: float
    vlen: nfft
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/num_integrations]*nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1000'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: integration_time
  id: parameter
  parameters:
    label: Integration Time (seconds)
    value: '60'
  states: {}
- name: obs_duration
  id: parameter
  parameters:
    label: Observation duration (seconds)
    type: intx
    value: '60'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: nfft
    width1: '2'
    x_axis_label: '"Frequency (MHz)"'
    x_start: 1420.405-samp_rate*1e-6/2
    x_step: samp_rate*1e-6/nfft
    y_axis_label: '"Power spectral density"'
    ymax: '5'
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ATA_HI
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ATA_HI
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.1.50.11:5555
    comment: Group 2 shall change the port from 5555 to 5556
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_head_0, '0', fft_vxx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_file_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_head_0, '0']
- [fft_vxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [zeromq_sub_source_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
