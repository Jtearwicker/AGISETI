options:
  parameters:
    author: jtear
    generate_options: qt_gui
    id: ATA_HI_Live
    output_language: python
    title: ATA Hydrogen Live
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: int(integration_time*samp_rate/nfft)
  states: {}
- name: integration_time
  id: variable
  parameters:
    value: '1'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: decimation
    type: float
    vlen: nfft
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1e-9]*nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1000'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: nfft
    x_axis_label: '"Velocity (km/sec)"'
    x_start: 3e5*(1-(1420.405-samp_rate*1e-6/2)/1420.405)
    x_step: 3e5*(1-((samp_rate*1e-6)/nfft)/1420.405)-3e5
    y_axis_label: '"Power spectral density"'
    ymax: '5'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: nfft
    x_axis_label: '"Frequency (MHz)"'
    x_start: 1420.405-samp_rate*1e-6/2
    x_step: samp_rate*1e-6/nfft
    y_axis_label: '"Power spectral density"'
    ymax: '5'
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ATA_HI_Live
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ATA_HI_Live
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.1.50.11:5555
    comment: Group 2 shall change the port from 5555 to 5556
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_integrate_xx_0, '0']
- [zeromq_sub_source_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
