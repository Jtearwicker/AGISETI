options:
  parameters:
    author: jtear
    generate_options: qt_gui
    id: Key_fob_test
    output_language: python
    title: Key FOB Detector
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 315e6
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 315e6
    fftsize: '4096'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: 315e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
