options:
  parameters:
    author: jtear
    generate_options: qt_gui
    id: ATA_HI_File_View
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\jtear\OneDrive\Documents\01_44_56_+60_40_23
    repeat: 'True'
    type: float
    vlen: nfft
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: nfft
    width1: '2'
    x_axis_label: '"Frequency (MHz)"'
    x_start: 1420.405-samp_rate*1e-6/2
    x_step: samp_rate*1e-6/nfft
    y_axis_label: '"Power spectral density"'
    ymax: '5'
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_vector_sink_f_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
